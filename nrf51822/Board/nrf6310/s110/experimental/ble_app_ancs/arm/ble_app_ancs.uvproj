# Keil uVision project ble_app_ancs.uvproj, settings and files
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: ble_app_ancs +hex
  c flags: Optim=1
  c define: NRF51 DEBUG_NRF_USER BOARD_NRF6310 BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: ..;..\..\..\..\..\..\Include;..\..\..\..\..\..\Include\app_common;..\..\..\..\..\..\Include\ble;..\..\..\..\..\..\Include\ble\device_manager;..\..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\..\Include\sd_common;..\..\..\..\..\..\Include\ext_sensors;..\..\..\..\..\..\Include\s110;..\..\..\..\..\..\Include\sdk
  memory RVCT4: ROM 0x00016000 size 0x00029000
  memory RVCT9: RAM 0x20002000 size 0x00002000
  group Startup Code
    ../../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ../../../../../../Source/templates/: system_nrf51.c
  group Source Code
    ../: main.c
  group Services
    ../: ble_ancs_c.c
  group Libraries
    ../../../../../../Source/ble/: ble_error_log.c ble_advdata.c ble_conn_params.c ble_debug_assert_handler.c
    ../../../../../../Source/app_common/: app_timer.c app_trace.c app_button.c app_gpiote.c pstorage.c
    ../../../../../../Source/simple_uart/: simple_uart.c
    ../../../../../../Source/ble/device_manager/: device_manager_peripheral.c
    ../../../../../../Source/ext_sensors/nRF6350/: nRF6350.c
    ../../../../../../Source/twi_master/: twi_hw_master.c
    ../../../../../../Source/sd_common/: softdevice_handler.c
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  cpu: as above
  output: ble_app_ancs +hex
  c flags: Optim=1
  c define: NRF51 DEBUG_NRF_USER BOARD_NRF6310 BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x00016000 size 0x00009000
  memory RVCT9: RAM 0x20002000 size 0x00002000
